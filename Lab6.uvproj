# Keil uVision project Lab6.uvproj, settings and files
target Lab6 (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab6
  c flags: Optim=1
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s lab6.s LCD.s pll.s SysTick.s
  group Library
    ../driverlib/rvmdk/: driverlib.lib
